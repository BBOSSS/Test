# Keil uVision project STM32_OV7620.uvprojx, settings and files
target STM32_OV7620 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_OV7620 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F10x_HD
  c include: .\library\inc;.\interrupt;.\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./startup/: cortexm3_macro.s stm32f10x_vector.s
  group interrupt
    ./interrupt/: stm32f10x_it.c
  group library
    ./library/src/: configuration.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c
  group src
    ./src/: main.c
software components: CMSIS:CORE 5.0.1
